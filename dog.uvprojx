# Keil uVision project dog.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dog +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Libraries\CMSIS;.\Libraries\STM32F10x_FWLib\inc;.\SRC\applications;.\SRC\drivers;.\build
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Libraries
    ./Libraries/CMSIS/: system_stm32f10x.c stm32f10x_it.c core_cm3.c startup_stm32f10x_md.s
    ./Libraries/STM32F10x_FWLib/src/: stm32f10x_gpio.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group drivers
    ./SRC/drivers/: DT.c filter.c hcsr04.c mpu6050.c mpuiic.c oled.c oled_spi.c openmv.c pwm.c sys.c time.c usart.c uart2.c usart3.c oledfont.h mpu9250.c SCS.c SCSCL.c SCSerail.c INST.h encoder.c exti.c motor.c
    ./SRC/applications/: my_math.c servo.c
  group applications
    ./SRC/applications/: config.c control.c Scheduler.c show.c main.c
